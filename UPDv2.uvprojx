# Keil uVision project UPDv2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UPDv2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src;.\STM32F0xx_StdPeriph_Driver;..\Project_UPD_v_2;..\Project_UPD_LSM6DSl;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;.\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;.\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;.\Middlewares\Third_Party\FreeRTOS\Source;..\GNSSGSMmodemV2
  memory RVCT4: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x200000c8 size 0x3f38
  group user
    ./: main.c base64.c freertos.c sim800.c
  group spl
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_spi.c stm32f0xx_iwdg.c
  group FreeRTOS
    ./Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
